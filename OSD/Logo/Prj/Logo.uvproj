# Keil uVision project Logo.uvproj, settings and files
target Logo (MCS-51)
  device: AT89S53 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: Logo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\Inc;..\..\..\UserConfig;..\..\..\UserConfig\Prj config
  group LogoDat
    ../: Osd_LogoFontDat.c
